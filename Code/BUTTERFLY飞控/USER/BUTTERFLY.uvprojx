# Keil uVision project BUTTERFLY.uvprojx, settings and files
target BUTTERRFLY-V4.6.2 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Four_Axis +hex
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\mylib;..\MPU6050_Lib\inc;..\Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER/Hardware_Control
    ../Driver/: main.c delay.c drv_adc.c Led.c myiic.c NRF24L01.C SPI.c stm32f10x_it.c usart.c
    ../mylib/: usart2.c
  group MOTOR_Control
    ../mylib/: PID.c PWM_output.c Control_200Hz.c
  group MPU6050_DMP
    ../MPU6050_Lib/src/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_wwdg.c
    ../Driver/: system_stm32f10x.c
