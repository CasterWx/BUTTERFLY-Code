# Keil uVision project BUTTERFLY遥控器.uvprojx, settings and files
target BUTTERFLY_V4.6遥控 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Four_Axis +hex
  c define: STM32F03X_MD,USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\USER;..\CORE;..\mylib;..\MPU6050_Lib\inc;..\Driver;..\STM32072B_EVAL;..\STM32F03x_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../Driver/: main.c delay.c drv_adc.c Led.c NRF24L01.C SPI.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f0xx.s core_cm0.h
  group FWLIB
    ../STM32F03x_FWLib/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_gpio.c
